# Keil uVision project CaptureHandler.uvprojx, settings and files
target CaptureHandler (ARM-ADS)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: CaptureHandler +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 v6LangP=8 v6Lto=1
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\Module;..\Module\88w8801\lwip\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_ll_gpio.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_ll_rcc.c stm32f4xx_ll_utils.c stm32f4xx_ll_exti.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_ll_dma.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_ll_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dcmi.c dma.c spi.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group 88w8801
    ../Module/88w8801/core/: 88w8801_core.c 88w8801_firmware.c
    ../Module/88w8801/flash/: 88w8801_flash.c 88w8801_program.c
    ../Module/88w8801/sdio/: 88w8801_sdio.c
    ../Module/88w8801/wrapper/: 88w8801_wrapper.c
    ../Module/88w8801/lwip/api/: err.c
    ../Module/88w8801/lwip/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../Module/88w8801/lwip/core/ipv4/: autoip.c dhcp.c dhcpd.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c nat.c
    ../Module/88w8801/lwip/netif/: ethernet.c ethernetif.c
  group debug
    ../Module/debug/: debug.c
  group ov2640
    ../Module/ov2640/: ov2640.c sccb.c
  group st7735s
    ../Module/st7735s/: sbc_data.c st7735s.c
  group systime
    ../Module/systime/: systime.c
software components: CMSIS:CORE 5.6.0
